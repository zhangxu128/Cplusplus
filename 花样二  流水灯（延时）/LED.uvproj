# Keil uVision project LED.uvproj, settings and files
target Target 1 (MCS-51)
  device: SST89C59 SST
  cpu: IRAM(0-0xFF) XRAM(0-0xff) IROM(0-0xFFFF) CLOCK(33000000)
  output: LED
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c delay.c app.c
